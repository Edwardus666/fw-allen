# Keil uVision project Ccu.uvprojx, settings and files
target Ccu (ARM-ADS)
  device: GD32F403VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.3
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Ccu
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_RPDO,CFG_BLOCK_TRANS,CFG_EX_FRAME
  c misc: --diag_suppress=1295,188
  c include: ..\..\Src\CMSIS;..\..\Src\CMSIS\GD\GD32F403\Include;..\..\Src\..\..\Src\CMSIS\GD\GD32F403\Include;..\..\Src\GD32F403_standard_peripheral\Include;..\..\Src\..\..\Src\GD32F403_standard_peripheral\Include;..\..\Src\..\..\Src\Utilities;..\..\Src\Main;..\..\Src\Common;..\..\Src\Driver;..\..\Src\;..\..\Src\Base;..\..\Src\CanOpenSlave;..\..\Src\CanOpenSlave\Stack;..\..\Src\CanOpenSlave\Stack\drvTemplate;..\..\Src\CanOpenMaster;..\..\Src\Pms;..\..\Src\WhMeter;..\..\Src\485Node
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./: startup_gd32f403.s
  group CMSIS
    ../../Src/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group Peripherals
    ../../Src/GD32F403_standard_peripheral/Source/: gd32f403_adc.c gd32f403_bkp.c gd32f403_can.c gd32f403_crc.c gd32f403_ctc.c gd32f403_dac.c gd32f403_dbg.c gd32f403_dma.c gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_fwdgt.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_rtc.c gd32f403_sdio.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c gd32f403_wwdgt.c
  group Main
    ../../Src/Main/: gd32f403_it.c main.c systick.c Fsm.c Fsm.h Shell.c console.c console.h Sm.c Sm.h MemMap.c MemMap.h Nvds.c Nvds.h LogUser.c LogUser.h OtaFile.c OtaFile.h CcuLed.c CcuLed.h
  group Common
    ../../Src/common/: ArchDef.h CheckSum.c CheckSum.h CmdLine.c CmdLine.h CommChecker.c CommChecker.h Common.c Common.h CostTime.c CostTime.h crc16.c crc16.h crc32.c crc32.h DateTime.c DateTime.h debug.c Debug.h Led.c Led.h List.c List.h Log.c Log.h md5.c md5.h Message.c Message.h MsgDef.h Page.c Page.h queue.c queue.h RetCode.h SafeBuf.c SafeBuf.h StringEx.c StringEx.h SwTimer.c SwTimer.h typedef.h Threshold.c Threshold.h SectorMgr.c SectorMgr.h Record.c Record.h
  group Driver
    ../../Src/Driver/: DriverCan.c DriverIo.c DriverLed.c DriverUart.c DriverAdc.c DriverAdc.h DriverCan.h DriverIo.h DriverLed.h DriverUart.h RcuMap.c RcuMap.h DriverTimer.c DriverTimer.h NTC.c NTC.h NTCLib.c NTCLib.h AdcUse.c DriverFmc.c DriverFmc.h
  group Base
    ../../Src/Base/: CcuDef.h HwFwVer.c HwFwVer.h Obj.c Obj.h Sensor.c Sensor.h UtpDef.h UtpPdo.c UtpPdo.h BaseOd.c BaseOd.h
  group CanOpenMaster
    ../../Src/CanOpenMaster/: Emcy.c Emcy.h Frame.c Frame.h Master.c Master.h MasterNode.c MasterNode.h MasterSdo.c MasterSdo.h Od.c Od.h SdoDef.h SegmentProtocol.c SegmentProtocol.h Pdo.c Pdo.h BlockProtocol.c BlockProtocol.h
  group Pms
    ../../Src/Pms/: Pms.c Pms.h PmsMgr.c PmsMgr.h PmsOd.c PmsOd.h Bms.c Bms.h Charger.c Charger.h
  group CanOpenSlave
    ../../Src/CanOpenSlave/: CANopen.c CANopen.h CO_OD.c CO_OD.h Slave.c Slave.h CO_driver.c CO_driver.h UnitOD.c UnitOD.h
  group CoStack
    ../../Src/CanOpenSlave/stack/: CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c CO_trace.c crc16-ccitt.c
  group Rs485Node
    ../../Src/485Node/: SbwMgr.c SbwMgr.h ShelfLock.c ShelfLock.h ShelfLockOd.c ShelfLockOd.h Rs485Protocol.c Rs485Protocol.h Rs485ProtocolNode.c Rs485ProtocolNode.h
  group WhMeter
    ../../Src/WhMeter/: MeterProtocol.c MeterProtocol.h WhMeter.c WhMeter.h MeterOd.c MeterOd.h
